# Add other custom image features here to make them available
inherit image-feature-convenience-aliases