FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

hostname = "ottoYYWWXX"
