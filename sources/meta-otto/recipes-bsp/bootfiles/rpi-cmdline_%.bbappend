# Instead of using all the different switches, we just overwrite it.
CMDLINE = "dwc_otg.lpm_enable=0 console=serial0,115200 fbcon=map:2 root=/dev/mmcblk0p2 rootfstype=ext4 rootwait logo.nologo"