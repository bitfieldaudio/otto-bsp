# TODO: Make this work
# do_install in clang_git.bb tries to install files that this disables the generation of
#EXTRA_OECMAKE += "-DLLVM_ENABLE_PROJECTS='clang;lld'"

SRCREV ?= "e5123472201e997773cf6f677ab16c34b2952b4f"
