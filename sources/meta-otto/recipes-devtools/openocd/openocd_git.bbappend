EXTRA_OECONF_append = " --enable-bcm2835gpio"