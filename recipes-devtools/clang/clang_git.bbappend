# TODO: Make this work
# do_install in clang_git.bb tries to install files that this disables the generation of
#EXTRA_OECMAKE += "-DLLVM_ENABLE_PROJECTS='clang;lld'"
